# Keil uVision project F4IMU.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4IMU
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F407xx,EMPL_TARGET_STM32F4,MPU6500,ARM_MATH_CM4,  __CC_ARM
  c misc: --cpp --cpp11
  c include: ..\STM32F4xx_StdPeriph_Driver\inc;..\User;..\CMSIS\Include;..\CMSIS\Inc;..\eMPL;..\eMPL\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.cpp Timer.cpp stm32f4xx_it.c Cled.cpp Imu.cpp printf_.cpp AHRS.c Matrix.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dsi.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_qspi.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c
  group eMPL
    ../eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4l_math.lib arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
